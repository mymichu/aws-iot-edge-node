FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}-${PV}:"

COMPATIBLE_MACHINE_iot-edge = "iot-edge"
