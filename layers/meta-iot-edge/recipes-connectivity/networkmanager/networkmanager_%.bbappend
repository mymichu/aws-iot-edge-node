IMAGE_FEATURES += "wifi"